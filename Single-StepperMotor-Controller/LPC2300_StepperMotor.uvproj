# Keil uVision project LPC2300_StepperMotor.uvproj, settings and files
target Simulator (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000E7FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2300_UARTIrq
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0xe800
  group Startup Code
    ./: LPC2300.s
  group Source Code
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCB2300 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: StepperMotor
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0xe800
